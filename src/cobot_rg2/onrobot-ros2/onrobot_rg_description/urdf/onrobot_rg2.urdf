Commit message: rg2_urdf_modi

File: src/cobot_rg2/onrobot-ros2/onrobot_rg_description/urdf/onrobot_rg2.urdf (robot description, URDF)
Before this commit: robot onrobot-rg2, 8 links, 7 joints
Joints:
- joint joint0: origin xyz=0. 0. 0. rpy=0. 0. 1.57 -> xyz=0.004 0. 0. rpy=1.5708 0 1.5708
